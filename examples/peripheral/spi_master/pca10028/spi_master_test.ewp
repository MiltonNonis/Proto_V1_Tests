# IAR project spi_master_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51422-QFAA NordicSemi nRF51422-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NRF51; BOARD_PCA10028; BLE_STACK_SUPPORT_REQD; S110; SPI_MASTER_0_ENABLE; ACCELEROMETER_ENABLE
  ICCARM.CCDiagSuppress: Pe301,Pa082
  ICCARM.CCIncludePath2: ..; ..\pca10028; ..\devices; $NRF51_SDK$\components\drivers_nrf\hal; $NRF51_SDK$\components\drivers_nrf\spi_master; $NRF51_SDK$\components\libraries\gpiote; $NRF51_SDK$\components\libraries\scheduler; $NRF51_SDK$\components\libraries\timer; $NRF51_SDK$\components\libraries\util; $NRF51_SDK$\components\softdevice\s110\headers; $NRF51_SDK$\components\softdevice\common\softdevice_handler; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: spi_master_test.hex
  ILINK.IlinkOutputFile: spi_master_test.out
  ILINK.IlinkIcfFile: collar_nRF51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ./: bsp.c
    ../: main.c
  group devices
    ../devices/: SensorUtils.c
  group nordic/components/drivers_nrf/hal
    $NRF51_SDK$/components/drivers_nrf/hal/: nrf_delay.c
  group nordic/components/drivers_nrf/spi_master
    $NRF51_SDK$/components/drivers_nrf/spi_master/: spi_master.c
  group nordic/components/libraries/timer
    $NRF51_SDK$/components/libraries/timer/: app_timer.c
  group nordic/components/softdevice/common/softdevice_handler
    $NRF51_SDK$/components/softdevice/common/softdevice_handler/: softdevice_handler.c
